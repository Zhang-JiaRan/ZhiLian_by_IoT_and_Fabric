# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\library;.\user;.\System;.\Hardware;.\Hardware\HC-SR04;.\System\sys;.\Hardware\DHT11
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s system_stm32f10x.h core_cm3.h stm32f10x.h
  group Library
    ./library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./System/: Delay.c Delay.h
    ./System/sys/: sys.c sys.h
  group User
    ./user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Font.h mlx90614.c mlx90614.h Key.c Key.h rc522_config.c rc522_config.h rc522_function.c rc522_function.h bsp_SysTick.c bsp_SysTick.h bsp_led.c bsp_led.h usart1.c usart1.h usart2.c usart2.h timer2.c timer2.h timer3.c timer3.h timer4.c timer4.h mqtt.c mqtt.h wifi.c wifi.h control.c control.h led.c led.h dht22.c dht22.h AD.c AD.h lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h pic.h
